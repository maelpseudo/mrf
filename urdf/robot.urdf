Commit message: Update robot.urdf

File: urdf/robot.urdf (robot description, URDF)
Before this commit: robot my_robot, 4 links, 3 joints
Joints:
- joint Base: limit lower=0 upper=3.14159 effort=10 velocity=10 -> lower=-1.5708 upper=1.5708 effort=10 velocity=10
